Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [, QuantityTakeOffAddOnView, SpaceBoundary2ndLevelAddOnView], Option [Drawing Scale: 100.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Entire project], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: On], Option [Convert 2D symbols of Doors and Windows: Off], Option [Explode Composite and Complex Profile elements into parts: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Multi-skin complex geometries: Building element parts], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [IFC Site Location: At Project Origin], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: On], Option [Geometry to type objects: On], Option [Element Properties: On], Option [Properties To Export: All], Option [IFC Base Quantities: On], Option [Window Door Lining and Panel Parameters: On], Option [IFC Space boundaries: On], Option [ARCHICAD Zone Categories as IFC Space classification data: On]
File name: simple2.ifc
Time: 2025-06-10T12:14:27+02:00
Author: Architect
Organization: Building Designer Office
Written by: IfcOpenShell 0.8.2
Made in: Bonsai 0.8.2
Authorization: The authorising person

# IfcProject, Projekt-FZK-Haus
Description: Projekt FZK-House create by KHH Forschuungszentrum Karlsruhe
GSPset_TimeStamp - GS_TimeStamp: 9685146
Pset_ProjectCommon - ConstructionMode: Massivhaus; BuildingPermitId: 1234; GrossAreaPlanned: 288 m2

# IfcSite: LandUse, Gelaende
Description: Ebenes Gelaende; RefLatitude: 49, 6, 1, 566000; RefLongitude: 8, 26, 11, 540400; RefElevation: 110 m
Pset_SiteCommon - BuildingHeightLimit: 9 m; GrossAreaPlanned: 0 m2
BaseQuantities - GrossPerimeter: 0 m; GrossArea: 0 m2

# IfcBuilding: Wohnhaus, FZK-Haus
Description: FZK-Haus create by KHH / IAI / FZK
Pset_BuildingCommon - BuildingID: 5678; IsPermanentID: yes; SprinklerProtection: no; SprinklerProtectionAutomatic: no; OccupancyType: citygml:1000 (residential building); GrossPlannedArea: 120 m2; NumberOfStoreys: 2; YearOfConstruction: 2008; NetAreaPlanned: 120 m2
BaseQuantities - GrossFloorArea: 241.498 m2

# IfcStair, Wendeltreppe
Material: Holz
Pset_StairCommon - HandicapAccessible: no; IsExternal: no; FireExit: yes
AC_Pset_Name - Name: Wendeltreppe
ArchiCADProperties - Komplette Element-ID: Wendeltreppe; Kompakte Element-ID: Wendeltreppe; Ursprungsgeschoss: Erdgeschoss; Raumname: Wohnen; Raumnummer: 5; Ebene: Treppen; Typ: Treppen; Geschützt: no; Bibliothekselement-Name: Treppe_FZK-Haus; Baustoff / Mehrschichtiger Aufbau / Profil / Schraffur: Holz; Tragende Funktion: Nicht definiert; Lage: Nicht definiert; Element-Klassifizierung: Treppe; Umbau-Status: Bestand; Anzeigen auf Umbau-Filter: Alle relevanten Filter; Drehwinkel: 210 deg; Oberfläche: Allgemein
AC_Pset_Treppe_FZK-Haus - 2D Hotspots in 3D zeigen: yes; Geschoßabhängig: yes; Kein Bruch im Gesch. oberhalb: yes; Strichlinien oberhalb Bruch: yes; Linientyp unter Einsetzgeschoß: 4; Symbol maßstabunabhängig: no; Trittlinien: no; Pfeil: no; Detail: no; Pfeil Auf/Ab: no; Schraffurtyp: Leer; 2D-Detaillierungsgrad: Maßstababhängig; Einfache/mittelmässige Modifizierung bei (iScaleChangeSM): 999; Einfache/mittelmässige Modifizierung bei (gs_ScaleChangeSM): 100; Mittelmässige/detaillierte Modifizierung bei (iScaleChangeMD): 999; Mittelmässige/detaillierte Modifizierung bei (gs_ScaleChangeMD): 50; 2D-Symbol Typ: Typ 11; Symbol Gruppentyp: 6; Linientyp sichtbare Struktur: 1; Linientyp unsichtbare Struktur: 4; Typ Bruchsymbol: Gerade; Hintergrund Schraffur-Typ: Leer; Schraffurhintergrund-Stift (gs_bgf_back_pen): Transparent; Schraffur über Bruchlinie: no; Lauflinie zeigen: yes; Lauflinie über Bruch zeigen: yes; Lauflinietyp (gs_walkline_type): 1; Lauflinietyp über Bruchlinie: 4; Symbol Lauflinie-Startpunkt (gs_StartEndStyle): Typ 1; Schraffur-Stift (0-Kein) (gs_StartEndFillPen): Transparent; Nummerierung zeigen (gs_show_numbering): yes; Beginnt von...: 1; Schriftgröße (mm) (gs_numb_text_size): 1; Schriftgröße (Punkt) (gs_numb_text_size_pt): 2.83; Ausrichtung (gs_numb_orient): Lesbar; Text umklappen: Kein; Unten-Text: Ab; Schriftgröße (mm) (gs_updown_text_size): 1; Schriftgröße (Punkt) (gs_updown_text_size_pt): 2.83; Ausrichtung (gs_updown_orient): Parallel mit Lauflinie; Text (gs_riserun_text): yes; Format: Anzahl x Auftritt x Steigung; Eigener Text: Anwendertext; Steigung Text: STG; Schriftgröße (mm) (gs_riserun_text_size): 1; Schriftgröße (Punkt) (gs_riserun_text_size_pt): 2.83; Ausrichtung (gs_riserun_orient): Lesbar; Übernehme Projektpräferenzen: yes; Schriftgröße (mm) (gs_desc_text_size): 1; Schriftgröße (Punkt) (gs_desc_text_size_pt): 2.83; Schrifttyp: Arial; Handlauf im Grundriss zeigen: yes; Pfosten Symbol-Typ: Typ 1; Linientyp (gs_handrail_linetype): 1; Linientyp Pfosten: 1; Handlauf-Achsenlinie zeigen: yes; Linientyp (gs_rail_axis_linetype): 1; Wangen im Grundriss zeigen: yes; Plattenlinie: 1; Geschossabhängig: yes; Linientyp unter Ursprungsgeschoss: 4; Bruchlinie: yes; 2D-unter Bruchsymbol zeigen: yes; 2D-über Bruchsymbol zeigen: yes; Stufen zeigen: yes; Linientyp (gs_story_line_type): 1; Lauflinietyp (gs_story_walkline_type): 1; Nummerierung zeigen (gs_story_shownum): yes; Oben Oberflächenmaterial (gs_up_mat): Anstrich; Oben Oberflächenmaterial (gs_up_mat_temp): Anstrich; Unten Oberflächenmaterial (gs_bot_mat): Anstrich; Unten Oberflächenmaterial (gs_bot_mat_temp): Anstrich; Seite Oberflächenmaterial (gs_side_mat): Anstrich; Seite Oberflächenmaterial (gs_side_mat_temp): Anstrich; Setzstufe Oberflächenmaterial (gs_raiser_mat): Anstrich; Setzstufe Oberflächenmaterial (gs_raiser_mat_temp): Anstrich; Gleiche Oberflächenmaterialien (gs_link_mat): no; Schnitt-Schraffur (gs_sectfill_type): IWF01-24,0-001; Oben Oberflächenmaterial (gs_tr_up_mat): Kiefer, glänzend; Oben Oberflächenmaterial (gs_tr_up_mat_temp): Kiefer, glänzend; Front Oberflächenmaterial (gs_tr_front_mat): Kiefer, glänzend; Front Oberflächenmaterial (gs_tr_front_mat_temp): Kiefer, glänzend; Setzstufe Oberflächenmaterial (gs_tr_riser_mat): Kiefer, glänzend; Setzstufe Oberflächenmaterial (gs_tr_riser_mat_temp): Kiefer, glänzend; Gleiche Oberflächenmaterialien (gs_link_tr_mat): no; Schnitt-Schraffur (gs_tr_sectfill_type): IWF01-24,0-001; Strukturtyp: 1; Tragende Dicke: 0.1; Preis: 0; Gruppe (FM_Type): Andere; Gruppe (iFMType): 25; Gewicht: 0; Gewichteinheit: kg; Anzahl Geschosse: 0; Anzahl Zwischenpodeste: 0; Niveauhöhe: 0; Lichtraum: 0; Tragekapazität: 0; Rauchfreies Treppenhaus: no; Stufenlänge: 0; Konstruktion (ifc_StairType): 0; Anzahl der Steigungen: 0; Anzahl der Auftritte: 0
ArchiCADQuantities - Höhenangabe zum Projekt-Nullpunkt: 0 m; Höhe zu Geschoss: 0 m; Oberflächenbereich: 7.69295 m2; Netto-Volumen: 0.207907 m3; Fläche: 1 m2; Höhe (Z Größe): 2 m; Länge (A): 1 m; Volumen: 0.207907 m3; Breite (B): 1 m
AC_Equantity_Treppe_FZK-Haus - Höhe: 2 m; Untere Ebene: 1 m; Obere Ebene: 0 m; Symbolgröße: 0.1 m; - (gs_ArrowWidth): 0.4 m; - (gs_BegSymbWidth): 0.2 m; Steigungshöhe: 0 m; Stufenlänge: 0 m

# IfcDoorType, no part of this type: IFC Tür - Eine Öffnunsgrichtung
OperationType: SINGLE_SWING_LEFT; ParameterTakesPrecedence: yes
Tür Linien-Sachmerkmale - LiningDepth: 0.1 m; LiningThickness: 0.05 m; LiningOffset: 0.1 m
Türblatt-Sachmerkmale - Panel1 - PanelDepth: 0.04 m; PanelOperation: SWINGING; PanelWidth: 1; PanelPosition: MIDDLE

# Material: Leichtbeton 102890359
Pset_MaterialThermal - ThermalConductivity: 0; SpecificHeatCapacity: 0 J/kg/K
Pset_MaterialCommon - MassDensity: 0 kg/m3
AC_Pset_MaterialCustom - EmbodiedEnergy: 0; EmbodiedCarbon: 0

# Material: Radial Gradient Fill 1515460218
Pset_MaterialThermal - ThermalConductivity: 0; SpecificHeatCapacity: 0 J/kg/K
Pset_MaterialCommon - MassDensity: 0 kg/m3
AC_Pset_MaterialCustom - EmbodiedEnergy: 0; EmbodiedCarbon: 0

# Material: Stahlbeton 65690
Pset_MaterialThermal - ThermalConductivity: 0; SpecificHeatCapacity: 0 J/kg/K
Pset_MaterialCommon - MassDensity: 0 kg/m3
AC_Pset_MaterialCustom - EmbodiedEnergy: 0; EmbodiedCarbon: 0

# Material: Solid 397409098
Pset_MaterialThermal - ThermalConductivity: 0; SpecificHeatCapacity: 0 J/kg/K
Pset_MaterialCommon - MassDensity: 0 kg/m3
AC_Pset_MaterialCustom - EmbodiedEnergy: 0; EmbodiedCarbon: 0
