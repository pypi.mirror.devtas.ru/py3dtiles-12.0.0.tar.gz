Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [, QuantityTakeOffAddOnView, SpaceBoundary2ndLevelAddOnView], Option [Drawing Scale: 100.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Entire project], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: On], Option [Convert 2D symbols of Doors and Windows: Off], Option [Explode Composite and Complex Profile elements into parts: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Multi-skin complex geometries: Building element parts], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [IFC Site Location: At Project Origin], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: On], Option [Geometry to type objects: On], Option [Element Properties: On], Option [Properties To Export: All], Option [IFC Base Quantities: On], Option [Window Door Lining and Panel Parameters: On], Option [IFC Space boundaries: On], Option [ARCHICAD Zone Categories as IFC Space classification data: On]
File name: small.ifc
Time: 2025-05-27T09:57:08+02:00
Author: Architect
Organization: Building Designer Office
Written by: IfcOpenShell 0.8.2
Made in: Bonsai 0.8.2
Authorization: The authorising person

# IfcProject, Projekt-FZK-Haus
Description: Projekt FZK-House create by KHH Forschuungszentrum Karlsruhe
GSPset_TimeStamp - GS_TimeStamp: 9685146
Pset_ProjectCommon - ConstructionMode: Massivhaus; BuildingPermitId: 1234; GrossAreaPlanned: 288 m2

# IfcSite: LandUse, Gelaende
Description: Ebenes Gelaende; RefLatitude: 49, 6, 1, 566000; RefLongitude: 8, 26, 11, 540400; RefElevation: 110 m
Pset_SiteCommon - BuildingHeightLimit: 9 m; GrossAreaPlanned: 0 m2
BaseQuantities - GrossPerimeter: 0 m; GrossArea: 0 m2

# IfcBuilding: Wohnhaus, FZK-Haus
Description: FZK-Haus create by KHH / IAI / FZK
Pset_BuildingCommon - BuildingID: 5678; IsPermanentID: yes; SprinklerProtection: no; SprinklerProtectionAutomatic: no; OccupancyType: citygml:1000 (residential building); GrossPlannedArea: 120 m2; NumberOfStoreys: 2; YearOfConstruction: 2008; NetAreaPlanned: 120 m2
BaseQuantities - GrossFloorArea: 241.498 m2

# IfcBuildingStorey (2)
In: FZK-Haus
Name | LongName | Elevation (m) | NetHeight (m) = GrossHeight (m) = Height (m) | GrossFloorArea (m2)
Erdgeschoss | ACID00000001-0000-0000-0000-000000000000 | 0 | 2.7 | 119.824
Dachgeschoss | ACID00000002-0000-0000-0000-000000000000 | 2.7 | 2 | 121.674

# IfcSpace (7)
Classification: 000 Allgemeines
Pset_SpaceCommon - Category: Allgemeines
Pset_SpaceThermalRequirements - AirConditioning: no
ArchiCADProperties - Typ: Raumstempel; Geschützt: no; Bibliothekselement-Name: Allgemeiner Raumstempel; Element-Klassifizierung: Raum; Umbau-Status: Bestand; Anzeigen auf Umbau-Filter: Alle relevanten Filter; Deckschraffur: Unnamed; Oberfläche: Farbe, matt; Geschoss für Oberkantenverknüpfung: Nicht verknüpft; Einheitliche Oberfläche: yes; Raumkategorie: Allgemeines; Raumflächen-Code: 000
AC_Pset_Allgemeiner_Raumstempel - Schriftgröße [mm]: 3; Wandabzugsfläche: 0; Fassaden- Abzugsfläche: 0; Stützenabzugsfläche: 0; Schraffurabzugsfläche: 0; Dach Oberflächenbereich an der Unterseite: 0; Decke Oberflächenbereich an der Oberseite: 0; Decke Oberflächenbereich an der Unterseite: 0; Unterzugoberfläche unten: 0; Oberer Oberflächenbereich der Wandeinsätze: 0; Oberfläche Wandnischen hinten: 0; Seite Oberflächenbereich der Wandeinsätze: 0; Raumpolygon (Brutto, Netto): 0; ID zeigen: no; ID zeigen als...: 1; Schraffur-Typ: Leer; Schraffur-Stift: Transparent; Schraffurhintergrund-Stift: Transparent
BaseQuantities - FinishFloorHeight: 0 m
ArchiCADQuantities - Höhe zu Geschoss: 0 m; Basislevel: 0 m; Stützenabzugsfläche: 0 m2; Schraffurabzugsfläche: 0 m2; Wandabzugsfläche: 0 m2; Fußbodendicke: 0 m; Durchbruch Umfang: 0 m; Anzahl der Stützen: 0; Anzahl der Lichtquelle: 0; Abstand Oberkante: 0 m; Abstand zu Ursprungsgeschoss: 0 m; Heizkörpernische Oberflächenbereich hinten: 0 m2; Heizkörpernische Oberflächenbereich seitlich: 0 m2; Heizkörpernische Oberflächenbereich oben: 0 m2
AC_Equantity_Allgemeiner_Raumstempel - Gesamtlänge aller Bodenkanten: 0 m; Höhenkote OK Rohdecke: 0 m; Dicke Bodenaufbau: 0 m
Name | In | LongName = ArchiCADProperties, Raumname = AC_Pset_Allgemeiner_Raumstempel, Raumname | HandicapAccessible = NaturalVentilation | SpaceTemperatureMax (C) = SpaceTemperatureMin (C) = SpaceTemperatureSummer (C) = SpaceTemperatureWinter (C) | Name = Komplette Element-ID = Kompakte Element-ID = ArchiCADProperties, Raumnummer = AC_Pset_Allgemeiner_Raumstempel, Raumnummer | Ursprungsgeschoss | Ebene | AC_Pset_Allgemeiner_Raumstempel, Gemessene Fläche = Gemessene Nettofläche = Unterer Oberflächenbereich = GrossFloorArea (m2) = GrossCeilingArea (m2) = Oberflächenbereich (m2) = Fläche (m2) = ArchiCADQuantities, Gemessene Fläche (m2) = Nettofläche (m2) | Anzahl aller Raumecken = Anzahl der Ecken | Anzahl hereinragender Raumecken = Anzahl der Unterzüge = Anzahl der konkaven Ecken | Oberfläche Umfassungswände = NetWallArea (m2) = Wand-Oberflächenbereich (m2) | Fläche der Türen = Türen-Oberflächenbereich (m2) | Fläche der Fenster = Fenster-Oberflächenbereich (m2) | Abzugsfläche unter Dach = AC_Pset_Allgemeiner_Raumstempel, Gesamtabzugsfläche = Niedrige Abzugsfläche (m2) = ArchiCADQuantities, Gesamtabzugsfläche (m2) | AC_Pset_Allgemeiner_Raumstempel, Reduzierte Fläche = Raumflächen Reduzierung (m2) | Raumfläche Faktor = ArchiCADQuantities, Reduzierte Fläche (m2) | AC_Pset_Allgemeiner_Raumstempel, Berechnete Fläche (NRF) = NetFloorArea (m2) = SpaceNetFloorAreaBOMA (m2) = SpaceUsableFloorAreaBOMA (m2) = NetCeilingArea (m2) = ArchiCADQuantities, Berechnete Fläche (NRF) (m2) | Raumvolumen = NetVolume (m3) = Netto-Volumen (m3) | Begrenzung Oberflächenbereich | Oberer Oberflächenbereich | Dach Oberflächenbereich an der Oberseite | Unterzug Oberflächenbereich an der Oberseite | Zeichensatz 1 | Height (m) = FinishCeilingHeight (m) = ClearHeight (m) = Höhe (m) = Raumhöhe (m) | GrossWallArea (m2) | GrossPerimeter (m) = NetPerimeter (m) = ArchiCADQuantities, Nettoumfang (m) = Umfang (m) = Raumumfang (m) = AC_Equantity_Allgemeiner_Raumstempel, Nettoumfang (m) | GrossVolume (m3) | Höhenangabe zum Projekt-Nullpunkt (m) | Türen Breite (m) = Summe Öffnungsbreite Türen (m) | Anzahl der Türen | Anzahl der Objekte | Anzahl der Wandelemente | Anzahl der Fenster | Wand Umfang (m) = Gesamtlänge Raumumfassung (m) | Fenster Breite (m) = Summe Öffnungsbreite Fenster (m)
4 | Erdgeschoss | Schlafzimmer | yes | 20 | 4 | Erdgeschoss | Räume | 22.0725 | 4 | 0 | 40.9211 | 1.77885 | 4.8 | 0 | 22.0725 | 0.97 | 21.4103 | 55.1812 | 47.5 | 22.0725 | 0 | 0 | Arial Westlich | 2.5 | 47.5 | 19 | 55.1812 | 0 | 0.885 | 1 | 0 | 4 | 2 | 19 | 4
3 | Erdgeschoss | Bad | yes | 24 | 3 | Erdgeschoss | Räume | 12.5027 | 4 | 0 | 31.2212 | 1.77885 | 2.4 | 0 | 12.5027 | 0.97 | 12.1276 | 31.2568 | 35.4 | 12.5027 | 0 | 0 | Arial Westlich | 2.5 | 35.4 | 14.16 | 31.2568 | 0 | 0.885 | 1 | 0 | 4 | 1 | 14.16 | 2
2 | Erdgeschoss | Buero | yes | 20 | 2 | Erdgeschoss | Räume | 12.985 | 4 | 0 | 29.4712 | 1.77885 | 4.8 | 0 | 12.985 | 0.97 | 12.5954 | 32.4625 | 36.05 | 12.985 | 0 | 0 | Arial Westlich | 2.5 | 36.05 | 14.42 | 32.4625 | 0 | 0.885 | 1 | 0 | 4 | 2 | 14.42 | 4
5 | Erdgeschoss | Wohnen | yes | 20 | 5 | Erdgeschoss | Räume | 25.9886 | 5 | 0 | 27.9387 | 4.77375 | 4.8 | 0 | 25.9886 | 0.97 | 25.2089 | 64.9714 | 53.575 | 25.9886 | 0 | 0 | Arial Westlich | 2.5 | 37.5125 | 21.43 | 64.9714 | 0 | 2.01 | 1 | 1 | 3 | 2 | 15.005 | 4
1 | Erdgeschoss | Flur |  | 15 | 1 | Erdgeschoss | Räume | 11.5314 | 7 | 1 | 27.8103 | 7.36665 | 0 | 0 | 11.5314 | 0.97 | 11.1855 | 28.6552 | 44.154 | 10.8094 | 0 | 0.722 | Arial Westlich | 2.5 | 35.177 | 17.7 | 28.8285 | 0 | 3.665 | 4 | 0 | 5 | 0 | 14.09 | 0
6 | Erdgeschoss | Küche |  | 20 | 6 | Erdgeschoss | Räume | 16.3055 | 5 | 0 | 24.2125 | 0 | 4.8 | 0 | 16.3055 | 0 | 16.3055 | 40.7636 | 40.525 | 16.3055 | 0 | 0 | Arial Westlich | 2.5 | 29.0125 | 16.21 | 40.7636 | 0 | 0 | 0 | 0 | 3 | 2 | 11.605 | 4
7 | Dachgeschoss | Galerie |  | 20 | 7 | Dachgeschoss | ARCHICAD-Ebene | 107.16 | 4 | 0 | 51.9425 | 0 | 2 | 32.6508 | 74.5092 | 1 | 74.5092 | 217.532 | 53.5127 | 0 | 123.738 | 0 | Courier New Westlich | 4 | 53.9425 | 41.6 | 428.64 | 2.7 | 0 | 0 | 37 | 4 | 2 | 41.6 | 2

# IfcDoor: Schiebetür_3-teilig, Terrassentuer
In: Erdgeschoss
Type - OperationType: DOUBLE_DOOR_SLIDING; ParameterTakesPrecedence: no
Type - Tür Linien-Sachmerkmale - LiningDepth: 0.1 m; LiningThickness: 0.05 m
Type - Türblatt-Sachmerkmale - Panel1 - PanelDepth: 0.04 m; PanelOperation: SLIDING; PanelPosition: LEFT
Type - Türblatt-Sachmerkmale - Panel2 - PanelDepth: 0.04 m; PanelOperation: SLIDING; PanelPosition: RIGHT
OverallHeight: 2.375 m; OverallWidth: 2.01 m
Pset_DoorCommon - ThermalTransmittance: 1.4
AC_Pset_Name - Name: Terrassentuer
ArchiCADProperties - Komplette Element-ID: Terrassentuer; Kompakte Element-ID: Terrassentuer; Ursprungsgeschoss: Erdgeschoss; Raumname: Wohnen; Raumnummer: 5; Ebene: Außenwände; Typ: Tür; Geschützt: no; Bibliothekselement-Name: Schiebetür_3-teilig; Baustoff / Mehrschichtiger Aufbau / Profil / Schraffur: Solid; Tragende Funktion: Nicht definiert; Lage: Nicht definiert; Element-Klassifizierung: Tür; Umbau-Status: Bestand; Anzeigen auf Umbau-Filter: Alle relevanten Filter; Marker-Text: 1; zu Raum: Wohnen; Ausrichtung: R; Zu Raum-Nummer: 5; Wandstruktur: Leichtbeton 102890359; Nominale B x H: 2,01x2,37; Nominale B x H x T: 2,01x2,37x0,30
AC_Pset_Schiebetür_3-teilig - Oberlicht (gs_kamp): no; Sprossen_horizontal: 3; Sprossen_vertikal: 1; Türklinke (gs_handle): yes; Typ_Türklinke: Knopf; Material_Stock: Kiefer, glänzend; Material_Türblatt: Kiefer, glänzend; Material_Glas: Glas; Material_Türklinke: Kupfer; Schwelle im 2D: no; Schwelle füllen: yes; Symbol Abbruch / Neubau: Kein; Schraffurtyp: Solid; Grundriss: Masstababhängig; Schnitt / Ansicht: Masstababhängig; 3D: Komplett; Nominalmaß=Durchgangslichte: no; Preis: 0; Glasfläche: 0; Umfang der Glasfläche: 0; Gruppe: Tür; Gewicht: 0; Gewichteinheit: kg; IFC Betrieb (ifc_optype): 7; IFC Betrieb (ifc_optypestr): Zweiflügeltür - Schiebeflügel; Öffnungswinkel im 2D: 90 deg; Öffnungswinkel im 3D: 0 deg; Schwelle (gs_kk): yes; Linientyp_Schwelle: 1; Wandkontur (0-Keine,1-Voll,2-Seite,3-Länge): 2; Fixpunte 0-Kein,1-2D,2-3D,3-Alle: 3; Showing 2D Hotspots in 3D: yes; Hole Has Wall's Side Material: no; Hole Material's Split is Curved: no; Show Editable Hotspots: yes
BaseQuantities - Height: 2.375 m; Width: 2.01 m; Perimeter: 8.77 m; Area: 4.77375 m2; Volume: 0.135434 m3; Depth: 0.3 m
ArchiCADQuantities - Höhenangabe zum Projekt-Nullpunkt: 0 m; Höhe zu Geschoss: 0 m; Höhe: 2.375 m; Oberflächenbereich: 14.3366 m2; Netto-Volumen: 0.135434 m3; Breite: 2.01 m; Dicke: 0.1 m; F/T nominale Brüstungs-/Schwellenhöhe: 0 m; F/T Brüstungs-/Schwellenhöhe auf der Anschlagseite: 0 m; F/T Brüstungs-/Schwellenhöhe gegenüber der Anschlagseite: 0 m; F/T nominale Sturzhöhe: 2.375 m; F/T Sturzhöhe auf der Anschlagseite: 2.375 m; F/T Sturzhöhe gegenüber der Anschlagseite: 2.375 m; F/T Öffnungsbreite auf der Anschlagseite: 2.01 m; F/T Öffnungsbreite gegenüber der Anschlagseite: 2.01 m; F/T Höhe der Öffnung auf der Anschlagseite: 2.375 m; F/T Höhe der Öffnung gegenüber der Anschlagseite: 2.375 m; F/T Oberfläche der Öffnung auf der Anschlagseite: 4.77375 m2; F/T Oberfläche der Öffnung gegenüber der Anschlagseite: 4.77375 m2; Nominale F/T Öffnungsbreite auf der Anschlagseite: 2.01 m; Nominale F/T Öffnungsbreite gegenüber der Anschlagseite: 2.01 m; Nominale F/T Höhe der Öffnung auf der Anschlagseite: 2.375 m; Nominale F/T Höhe der Öffnung gegenüber der Anschlagseite: 2.375 m; Nominale T/F Öffnungsoberfläche auf der Anschlagsseite: 4.77375 m2; Nominale T/F Öffnungsoberfläche auf der Seite gegenüber der Anschlagsseite: 4.77375 m2; F/T Volumen der Öffnung: 0.135434 m3; T/F Öffnung Nominaler Oberflächenbereich: 4.77375 m2; F/T nominales Volumen der Öffnung: 1.43213 m3; Brüstungshöhe: 0 m; Wanddicke: 0.3 m
AC_Equantity_Schiebetür_3-teilig - Höhe_Oberlicht (von oben): 0.5 m; Sprossenbreite: 0.025 m; Sprossenstärke: 0.025 m; Stockbreite: 0.05 m; Stockstärke: 0.1 m; Rahmenbreite: 0.05 m; Rahmenstärke: 0.05 m; Rahmenbreite_unten: 0.25 m; Schwellenhöhe: 0.005 m; Geöffnet um: 0 m; Z Dimension: 1 m; Brüstungshöhe zum aktuellen Geschoss: 0 m; Untere Ebene: 1 m; Obere Ebene: 0 m; Leaf Thickness: 0.04 m; AC Left Opening Oversize: 0 m; AC Right Opening Oversize: 0 m; AC Upper Opening Oversize: 0 m; AC Lower Opening Oversize: 0 m

# IfcDoorType, no part of this type: IFC Tür - Eine Öffnunsgrichtung
OperationType: SINGLE_SWING_LEFT; ParameterTakesPrecedence: yes
Tür Linien-Sachmerkmale - LiningDepth: 0.1 m; LiningThickness: 0.05 m; LiningOffset: 0.1 m
Türblatt-Sachmerkmale - Panel1 - PanelDepth: 0.04 m; PanelOperation: SWINGING; PanelWidth: 1; PanelPosition: MIDDLE

# Material: Leichtbeton 102890359
Pset_MaterialThermal - ThermalConductivity: 0; SpecificHeatCapacity: 0 J/kg/K
Pset_MaterialCommon - MassDensity: 0 kg/m3
AC_Pset_MaterialCustom - EmbodiedEnergy: 0; EmbodiedCarbon: 0

# Material: Radial Gradient Fill 1515460218
Pset_MaterialThermal - ThermalConductivity: 0; SpecificHeatCapacity: 0 J/kg/K
Pset_MaterialCommon - MassDensity: 0 kg/m3
AC_Pset_MaterialCustom - EmbodiedEnergy: 0; EmbodiedCarbon: 0

# Material: Stahlbeton 65690
Pset_MaterialThermal - ThermalConductivity: 0; SpecificHeatCapacity: 0 J/kg/K
Pset_MaterialCommon - MassDensity: 0 kg/m3
AC_Pset_MaterialCustom - EmbodiedEnergy: 0; EmbodiedCarbon: 0

# Material: Solid 397409098
Pset_MaterialThermal - ThermalConductivity: 0; SpecificHeatCapacity: 0 J/kg/K
Pset_MaterialCommon - MassDensity: 0 kg/m3
AC_Pset_MaterialCustom - EmbodiedEnergy: 0; EmbodiedCarbon: 0
